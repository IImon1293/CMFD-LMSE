# Repository IImon1293/CMFD-LMSE

## KiCad design CMFD-LMSE.kicad_pcb

Parts:
D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
GPIO1, GPIO2, GPIO3, GPIO4, GPIO5, GPIO6, GPIO7, GPIO8, GPIO9: Conn_01x03; CONN3_DF1B-3P_HIR
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO14580_Pad
IN1: Conn_01x02; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
J1, J7, J8, J9, J10, J11, J12: Conn_01x02; CON2_1X2_U_DF1BZ_HIR
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8, JP9: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm
R5, R6, R7, R8, R9, R10, R11, R12, R13: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15, R16, R17, R18, R19, R20, R21, R22, R23: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3.3V: JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP6.3 (B), JP7.3 (B), JP8.3 (B), JP9.3 (B); also elsewhere on the board
+BATT: IN1.2, JP1.1 (A), JP2.1 (A), JP3.1 (A), JP4.1 (A), JP5.1 (A), JP6.1 (A), JP7.1 (A), JP8.1 (A), JP9.1 (A), R23.1
/MCU/GPIO_1: R5.1; also elsewhere on the board
/MCU/GPIO_2: R6.1; also elsewhere on the board
/MCU/GPIO_3: R7.1; also elsewhere on the board
/MCU/GPIO_4: R8.1; also elsewhere on the board
/MCU/GPIO_5: R9.1; also elsewhere on the board
/MCU/GPIO_6: R10.1; also elsewhere on the board
/MCU/GPIO_7: R11.1; also elsewhere on the board
/MCU/GPIO_8: R12.1; also elsewhere on the board
/MCU/GPIO_9: R13.1; also elsewhere on the board
/MCU/GPIO_LM_1: J1.1; also elsewhere on the board
/MCU/GPIO_LM_2: J7.1; also elsewhere on the board
/MCU/GPIO_LM_3: J8.1; also elsewhere on the board
/MCU/GPIO_LM_4: J9.1; also elsewhere on the board
/MCU/GPIO_LM_5: J10.1; also elsewhere on the board
/MCU/GPIO_LM_6: J11.1; also elsewhere on the board
/MCU/GPIO_LM_7: J12.1; also elsewhere on the board
GND: D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), GPIO1.3, GPIO2.3, GPIO3.3, GPIO4.3, GPIO5.3, GPIO6.3, GPIO7.3, GPIO8.3, GPIO9.3, IN1.1, J1.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2; also elsewhere on the board
unnamed: D3.2 (A), R14.1
unnamed: D4.2 (A), R15.1
unnamed: D5.2 (A), R16.1
unnamed: D6.2 (A), R17.1
unnamed: D7.2 (A), R18.1
unnamed: D8.2 (A), R19.1
unnamed: D9.2 (A), R20.1
unnamed: D10.2 (A), R21.1
unnamed: D11.2 (A), R22.1
unnamed: D12.2 (A), R23.2
unnamed: GPIO1.1, R5.2, R22.2
unnamed: GPIO1.2, JP1.2 (C)
unnamed: GPIO2.1, R6.2, R21.2
unnamed: GPIO2.2, JP2.2 (C)
unnamed: GPIO3.1, R7.2, R20.2
unnamed: GPIO3.2, JP3.2 (C)
unnamed: GPIO4.1, R8.2, R19.2
unnamed: GPIO4.2, JP4.2 (C)
unnamed: GPIO5.1, R9.2, R18.2
unnamed: GPIO5.2, JP5.2 (C)
unnamed: GPIO6.1, R10.2, R17.2
unnamed: GPIO6.2, JP6.2 (C)
unnamed: GPIO7.1, R11.2, R16.2
unnamed: GPIO7.2, JP7.2 (C)
unnamed: GPIO8.1, R12.2, R15.2
unnamed: GPIO8.2, JP8.2 (C)
unnamed: GPIO9.1, R13.2, R14.2
unnamed: GPIO9.2, JP9.2 (C)

Notes on the sheet:
XT30
逆流時の過電圧保護

Parts:
C1, C6, C7, C9: 22µF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2, C5, C8: 0.1µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 47µF; CP_Radial_D5.0mm_P2.50mm
C10, C11: 1µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: MSS1P3L-M3/89A; DIODE_MSP3V3
D13: SS1P3L-M3/84A; DIODE_SS1P3L-M3&slash_84A_VIS-M
D16: LED; LED_D3.0mm
F2: MF-MSMF050-2; FUSE_F050-2
J2: Conn_01x02; CON2_1X2_U_DF1BZ_HIR
J3: ZX62-B-5PA_33_; HRS_ZX62-B-5PA_33_
L1: MH2029-300Y; IND_BOURNS_MH2029
R1, R26: 100k; RES_R0603_ROM-L
R27: 19.1K_0.1%; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28: 100K_1%; RES_R0603_ROM-L
R29: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30, R32: 100k; RES_R0603_ROM-M
R31: 150k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R37: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1, RV2, RV3: CG0603MLC-05E; VARC1608X56N; PARTREV E
TP1: UVB1; TestPoint_Pad_1.5x1.5mm
TP2: UD-1; TestPoint_Pad_1.5x1.5mm
TP3: UD+1; TestPoint_Pad_1.5x1.5mm
TP4: ST; TestPoint_Pad_1.5x1.5mm
U1: MPM3610GQV-Z; QFN3p0x5p0x1p6_MPM3610_MNP
U2: CH340E; MSOP-10_3x3mm_P0.5mm
U4: TPS2117DRLR; SOTFL50P160X60-8N; PARTREV A
U5: BD33IC0WEFJ-E2; HTSOP-J8_ROM-M

Connections:
+3.3V: C8.1, C11.1, R37.1, U2.7 (VCC), U2.10 (V3), U5.1 (VO), U5.2 (VO_S); also elsewhere on the board
/MCU/USART1_RX: U2.9 (RXD); also elsewhere on the board
/MCU/USART1_TX: U2.8 (TXD); also elsewhere on the board
/PowerAndUSB/D+: J3.3, RV2.1, TP3.1 (1_1), U2.1 (UD+)
/PowerAndUSB/D-: J3.2, RV1.1, TP2.1 (1_1), U2.2 (UD-)
/PowerAndUSB/USB_5V: C7.1, C9.1, F2.2, R29.1, U4.6 (VIN2)
/PowerAndUSB/VIN+: J2.2, L1.2
/PowerAndUSB/VIN_5V: C5.1, C6.1, R28.2, R30.1, R32.2, U1.7 (OUT), U1.8 (OUT), U1.9 (OUT), U4.3 (VIN1), U4.5 (MODE)
/PowerAndUSB/VOTGID: J3.4, RV3.2
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D16.1 (K), J2.1, J3.5, J3.SH1 (SHIELD), J3.SH2 (SHIELD__1), J3.SH3 (SHIELD__2), J3.SH4 (SHIELD__3), J3.SH5 (SHIELD__4), J3.SH6 (SHIELD__5), R26.1, R27.2, R29.2, R31.2, RV1.2, RV2.2, RV3.1, U1.3 (AGND), U1.12 (PGND), U1.13 (PGND), U1.14 (PGND), U2.3 (GND), U4.1 (GND), U5.3 (GND), U5.EPAD; also elsewhere on the board
unnamed: D1.2, D13.2 (ANODE), L1.1
unnamed: D16.2 (A), R37.2
unnamed: F2.1, J3.1, TP1.1 (1_1)
unnamed: R26.2, U1.18 (AAM)
unnamed: R1.2, U1.17 (EN)
unnamed: R27.1, R28.1, U1.1 (FB)
unnamed: R30.2, R31.1, U4.4 (PR1)
unnamed: R32.1, TP4.1 (1_1), U4.8 (ST)
SYS_5V: C10.1, U4.2 (VOUT), U4.7 (VOUT__1), U5.5 (EN), U5.8 (VCC); also elsewhere on the board
VIN: C1.1, C2.1, C4.1, D1.1, D13.1 (CATHODE), R1.1, U1.16 (IN)

Notes on the sheet:
Arduino Dueでは"USBVCC"
バリスタ
逆説保護
プルアップ
メモ Arduino Dueの回路図にあったXUSBをこちらでは削除している
USB-UART
USB 信号・電源
PGNDのエレクトリカルタイプを電源出力からパッシブに変更
電源入力
電源確認
5V 昇降圧回路
電源選択回路
テストポイント
オシロとかで値を読める
3.3V LDO

Parts:
C12, C13: 0.1µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D14, D17: LED; LED_D3.0mm
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_01x02; TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm
R33, R34: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R38: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R39: 200k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U6: MCP2562FD-H/SN; SOIC8-N_MC_MCH-L

Connections:
+3.3V: C13.1, R33.1, R34.1, U6.5 (VIO); also elsewhere on the board
/CAN/CAN_RX: D17.1 (K), U6.4 (RXD); also elsewhere on the board
/CAN/CAN_TX: D14.1 (K), U6.1 (TXD); also elsewhere on the board
GND: C12.2, C13.2, R39.2, U6.2 (VSS); also elsewhere on the board
unnamed: D14.2 (A), R33.2
unnamed: D17.2 (A), R34.2
unnamed: J4.1, J6.1, U6.7 (CANH)
unnamed: J4.2, R38.2
unnamed: J6.2, R38.1, U6.6 (CANL)
unnamed: R39.1, U6.8 (STBY)
SYS_5V: C12.1, U6.3 (VDD); also elsewhere on the board

Notes on the sheet:
MCR03SEQPF1200

Parts:
C28, C30: 6.8pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31, C34, C36, C37, C38, C41: 0.1µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C35: 4.7µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C40: 1µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C42, C43: 5.1pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C44, C45: 2.2µF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D18: LED; LED_D3.0mm
J5: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
R2, R3: 33; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R35: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R40: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW3: SW_SPDT; SlideSW
SW4: SW_Push; SW_PUSH-12mm
U7: STM32H503CBTx; LQFP-48_7x7mm_P0.5mm
X1: MU00525-32.768K; XTAL_MU00525_NDK
XTAL2: NX2016SA-24M-EXS00A-CS08891; NX2016SA_NDK

Connections:
+3.3V: C34.1, C35.1, C36.1, C37.1, C38.1, C40.1, C41.1, J5.1, SW3.2 (C), U7.1 (VBAT), U7.9 (VDDA), U7.24 (VDD), U7.36 (VDD), U7.48 (VDD); also elsewhere on the board
/CAN/CAN_RX: U7.25 (PB12); also elsewhere on the board
/CAN/CAN_TX: U7.26 (PB13); also elsewhere on the board
/MCU/GPIO_1: U7.13 (PA3); also elsewhere on the board
/MCU/GPIO_2: U7.14 (PA4); also elsewhere on the board
/MCU/GPIO_3: U7.15 (PA5); also elsewhere on the board
/MCU/GPIO_4: U7.16 (PA6); also elsewhere on the board
/MCU/GPIO_5: U7.17 (PA7); also elsewhere on the board
/MCU/GPIO_6: U7.18 (PB0); also elsewhere on the board
/MCU/GPIO_7: U7.19 (PB1); also elsewhere on the board
/MCU/GPIO_8: U7.20 (PB2); also elsewhere on the board
/MCU/GPIO_9: U7.21 (PB10); also elsewhere on the board
/MCU/GPIO_LM_1: U7.27 (PB14); also elsewhere on the board
/MCU/GPIO_LM_2: U7.28 (PB15); also elsewhere on the board
/MCU/GPIO_LM_3: U7.29 (PA8); also elsewhere on the board
/MCU/GPIO_LM_4: U7.30 (PA9); also elsewhere on the board
/MCU/GPIO_LM_5: U7.31 (PA10); also elsewhere on the board
/MCU/GPIO_LM_6: U7.32 (PA11); also elsewhere on the board
/MCU/GPIO_LM_7: U7.33 (PA12); also elsewhere on the board
/MCU/NRST: C31.1, J5.5, SW4.2, U7.7 (NRST); also elsewhere on the board
/MCU/PA13-JTMS-SWDIO: R3.2, U7.34 (PA13(JTMS)
/MCU/PA14-JTCK-SWCLK: R2.1, U7.37 (PA14(JTCK)
/MCU/USART1_RX: U7.11 (PA1); also elsewhere on the board
/MCU/USART1_TX: U7.12 (PA2); also elsewhere on the board
BOOT0: R35.2, U7.44 (BOOT0)
GND: C28.2, C30.2, C31.2, C34.2, C35.2, C36.2, C37.2, C38.2, C40.2, C41.2, C42.1, C43.1, C44.2, C45.2, D18.1 (K), J5.3, SW3.3 (A), SW4.1, U7.8 (VSSA), U7.23 (VSS), U7.35 (VSS), U7.47 (VSS), XTAL2.2, XTAL2.4; also elsewhere on the board
unnamed: C44.1, U7.22 (VCAP)
unnamed: C45.1, U7.46 (VCAP)
unnamed: D18.2 (A), R40.2
unnamed: J5.2, R2.2
unnamed: J5.4, R3.1
unnamed: R35.1, SW3.1 (B)
unnamed: R40.1, U7.38 (PA15(JTDI))
OSC32_IN: C42.2, U7.3 (PC14), X1.1
OSC32_OUT: C43.2, U7.4 (PC15), X1.2
OSC_IN: C30.1, U7.5 (PH0), XTAL2.1
OSC_OUT: C28.1, U7.6 (PH1), XTAL2.3

Notes on the sheet:
bypass capacitor
JTAG Clock
スチロール コンデンサかも
VDD
32.768kHz
VDDA
-> 36
Crystal
Write
JTAG Test Mode State
VBAT
ESR < 100mΩ
24MHz
BOOT
Lチカ 起動確認
-> 48
RESET
-> 24
JTAGコネクタ（没）

Board: 4 copper layers, 100.0 x 80.0 mm, 132 parts (0 on the bottom side), 88 nets.

Other parts of the board:
NRST: SW_Push; TactSW_6266

Their connections:
/MCU/NRST: NRST.2; also elsewhere on the board
GND: NRST.1; also elsewhere on the board

File jlcpcb/production_files/BOM-CMFD-LMSE.csv:

Comment,Designator,Footprint,LCSC,Quantity
0.1µF,"C12,C13,C2,C31,C34,C36,C37,C38,C41,C5,C8",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C125205,11
100K_1%,R28,RES_R0603_ROM-L,C25803,1
100k,"R1,R26,R30,R32",RES_R0603_ROM-L,C25803,4
10k,"R29,R35",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23192,2
120,R38,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C14709,1
150k,R31,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,C17470,1
19.1K_0.1%,R27,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C22897,1
1K,"R14,R15,R16,R17,R18,R19,R20,R21,R22,R23",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C21190,10
1k,"R33,R34,R37,R40",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C21190,4
1µF,"C10,C11,C40",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C15849,3
2.2µF,"C44,C45",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C86017,2
200k,R39,R_0805_2012Metric_Pad1.20x1.40mm_HandSolder,C17539,1
22µF,"C1,C6,C7,C9",C_1206_3216Metric_Pad1.33x1.80mm_HandSolder,C12891,4
33,"R2,R3",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23140,2
330,"R10,R11,R12,R13,R5,R6,R7,R8,R9",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23138,9
4.7µF,C35,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C69335,1
5.1pF,"C42,C43",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C6955114,2
6.8pF,"C28,C30",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C1679,2
BD33IC0WEFJ-E2,U5,HTSOP-J8_ROM-M,C2924218,1
CG0603MLC-05E,"RV1,RV2,RV3",VARC1608X56N,C840634,3
CH340E,U2,MSOP-10_3x3mm_P0.5mm,C99652,1
Conn_01x02,IN1,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,C431092,1
LED,D12,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C2286,1
LED,"D10,D11,D3,D4,D5,D6,D7,D8,D9",LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C2290,9
MCP2562FD-H/SN,U6,SOIC8-N_MC_MCH-L,C191415,1
MF-MSMF050-2,F2,FUSE_F050-2,C17313,1
MH2029-300Y,L1,IND_BOURNS_MH2029,C840593,1
MPM3610GQV-Z,U1,QFN3p0x5p0x1p6_MPM3610_MNP,C5183856,1
MSS1P3L-M3/89A,D1,DIODE_MSP3V3,C144285,1
MU00525-32.768K,X1,XTAL_MU00525_NDK,C528987,1
NX2016SA-24M-EXS00A-CS08891,XTAL2,NX2016SA_NDK,C6134314,1
SS1P3L-M3/84A,D13,DIODE_SS1P3L-M3&slash_84A_VIS-M,C2875475,1
STM32H503CBTx,U7,LQFP-48_7x7mm_P0.5mm,C17700273,1
TPS2117DRLR,U4,SOTFL50P160X60-8N,C22399676,1
ZX62-B-5PA_33_,J3,HRS_ZX62-B-5PA_33_,C132561,1
UD-1,TP2,TestPoint_Pad_1.5x1.5mm,,1
SW_SPDT,SW3,SlideSW,,1
Conn_01x03,GPIO3,CONN3_DF1B-3P_HIR,,1
Conn_01x02,J4,PinHeader_1x02_P2.54mm_Vertical,,1
SolderJumper_3_Open,JP2,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
SolderJumper_3_Open,JP3,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
Conn_01x02,J9,CON2_1X2_U_DF1BZ_HIR,,1
Conn_01x02,J7,CON2_1X2_U_DF1BZ_HIR,,1
LED,D14,LED_D3.0mm,,1
Conn_01x02,J10,CON2_1X2_U_DF1BZ_HIR,,1
SolderJumper_3_Open,JP8,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
ST,TP4,TestPoint_Pad_1.5x1.5mm,,1
LED,D18,LED_D3.0mm,,1
Conn_01x03,GPIO6,CONN3_DF1B-3P_HIR,,1
Conn_01x03,GPIO1,CONN3_DF1B-3P_HIR,,1
MountingHole_Pad,H4,MountingHole_3.2mm_M3_ISO14580_Pad,,1
Conn_01x03,GPIO7,CONN3_DF1B-3P_HIR,,1
Conn_01x03,GPIO5,CONN3_DF1B-3P_HIR,,1
MountingHole_Pad,H1,MountingHole_3.2mm_M3_ISO14580_Pad,,1
MountingHole_Pad,H3,MountingHole_3.2mm_M3_ISO14580_Pad,,1
Conn_01x02,J12,CON2_1X2_U_DF1BZ_HIR,,1
Conn_01x02,J11,CON2_1X2_U_DF1BZ_HIR,,1
Conn_01x05,J5,PinHeader_1x05_P2.54mm_Vertical,,1
Conn_01x03,GPIO9,CONN3_DF1B-3P_HIR,,1
Conn_01x03,GPIO4,CONN3_DF1B-3P_HIR,,1
LED,D17,LED_D3.0mm,,1
Conn_01x03,GPIO2,CONN3_DF1B-3P_HIR,,1
LED,D16,LED_D3.0mm,,1
SolderJumper_3_Open,JP9,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
SolderJumper_3_Open,JP5,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
Conn_01x02,J6,TerminalBlock_MaiXu_MX126-5.0-02P_1x02_P5.00mm,,1
Conn_01x03,GPIO8,CONN3_DF1B-3P_HIR,,1
MountingHole_Pad,H2,MountingHole_3.2mm_M3_ISO14580_Pad,,1
Conn_01x02,J1,CON2_1X2_U_DF1BZ_HIR,,1
SolderJumper_3_Open,JP7,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
SolderJumper_3_Open,JP4,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
UD+1,TP3,TestPoint_Pad_1.5x1.5mm,,1
Conn_01x02,J8,CON2_1X2_U_DF1BZ_HIR,,1
UVB1,TP1,TestPoint_Pad_1.5x1.5mm,,1
Conn_01x02,J2,CON2_1X2_U_DF1BZ_HIR,,1
47µF,C4,CP_Radial_D5.0mm_P2.50mm,,1
SolderJumper_3_Open,JP6,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
SolderJumper_3_Open,JP1,SolderJumper-3_P1.3mm_Open_Pad1.0x1.5mm,,1
SW_Push,NRST,TactSW_6266,,1

## Commit log (part)

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2026-06-20 First commit.
2026-06-20 backupファイルを消去
2026-06-20 今度こそバックアップディレクトリを追跡から解除
2026-06-26 回路図（ひとまず完成）
2026-06-29 抵抗器のフットプリントを策定
2026-06-29 バイパスコンデンサ37~41
